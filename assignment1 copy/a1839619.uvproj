# Keil uVision project a1839619.uvproj, settings and files
target Target 1 (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: a1839619
  group Source Group 1
    ./: START167.A66 main.c reg167.h driver.h driver.c pindefs.h serial.c serial.h stdtypes_c167.h adc.c adc.h gpio.h gpio.c timer.c timer.h
